options:
  parameters:
    generate_options: no_gui
    id: test
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: TX Antenna
    type: str
    value: '"TX1"'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filename
    repeat: 'True'
    type: complex
  states: {}
- name: filename
  id: parameter
  parameters:
    label: Filename
    type: str
    value: '"samples/HT/beacon_mcs0_lgi.raw"'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Channel Frequency (Centre)
    type: intx
    value: '2412000000'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: RF Gain
    type: intx
    value: '20'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: antenna
    args: bladerf=0
    bb_gain0: '20'
    bw0: bandwidth
    freq0: freq
    gain0: gain
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
